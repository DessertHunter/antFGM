# Keil uVision project ant_fgm_app_s310_pca10031.uvprojx, settings and files
target nrf51422_xxac_s310 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s310 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD BOARD_PCA10031 NRF_LOG_USES_RTT S310 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0 DEBUG
  c misc: --c99
  c include: .\ANT_FGM_Profile;.\ANT_FGM_Profile\pages;.\ANT_FGM_Profile\pages\logger;.\ANT_FGM_Profile\utils;.\bsp;.\config;.\config\pca10031;.\CR95HF;.\LibreSensor;.\nRF5_SDK10\components\toolchain;.\nRF5_SDK10\components\ant\ant_channel_config;.\nRF5_SDK10\components\ant\ant_key_manager;.\nRF5_SDK10\components\ant\ant_key_manager\config;.\nRF5_SDK10\components\ant\ant_stack_config;.\nRF5_SDK10\components\ant\ant_state_indicator;.\nRF5_SDK10\components\ble\ble_services\ble_bas;.\nRF5_SDK10\components\ble\ble_services\ble_dis;.\nRF5_SDK10\components\ble\ble_services\ble_gls;.\nRF5_SDK10\components\ble\ble_racp;.\nRF5_SDK10\components\ble\common;.\nRF5_SDK10\components\ble\device_manager;.\nRF5_SDK10\components\drivers_nrf\common;.\nRF5_SDK10\components\drivers_nrf\delay;.\nRF5_SDK10\components\drivers_nrf\gpiote;.\nRF5_SDK10\components\drivers_nrf\config;.\nRF5_SDK10\components\drivers_nrf\hal;.\nRF5_SDK10\components\drivers_nrf\pstorage;.\nRF5_SDK10\components\drivers_nrf\spi_master;.\nRF5_SDK10\components\drivers_nrf\uart;.\nRF5_SDK10\components\libraries\button;.\nRF5_SDK10\components\libraries\sensorsim;.\nRF5_SDK10\components\libraries\timer;.\nRF5_SDK10\components\libraries\trace;.\nRF5_SDK10\components\libraries\uart;.\nRF5_SDK10\components\libraries\util;.\nRF5_SDK10\components\softdevice\common\softdevice_handler;.\nRF5_SDK10\components\softdevice\s310\headers;.\segger_rtt
  asm define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD BOARD_PCA10028 S310 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002200 size 0x5e00
  group ANT_FGM_Profile
    ./ANT_FGM_Profile/: ANT_FGM.c
    ./ANT_FGM_Profile/pages/: ANT_FGM_Page_0.c ANT_FGM_Page_1.c ANT_FGM_Page_2.c ANT_FGM_Page_3.c ANT_FGM_Page_4.c
  group Application
    ./Application/: main.c main_Secret.c main_Secret.h
  group Board Support
    ./bsp/: bsp.c bsp_btn_ant.c
  group CR95HF
    ./CR95HF/: CR95HF.c CR95HF.h
  group Documentation
    ./Documentation/: Abstract.txt license.txt
  group LibreSensor
    ./LibreSensor/: LibreSensor.c LibreSensor.h LibreSensor_Secret.c LibreSensor_Secret.h
  group nRF_ANT
    ./nRF5_SDK10/components/ant/ant_channel_config/: ant_channel_config.c
    ./nRF5_SDK10/components/ant/ant_key_manager/: ant_key_manager.c
    ./nRF5_SDK10/components/ant/ant_stack_config/: ant_stack_config.c
    ./nRF5_SDK10/components/ant/ant_state_indicator/: ant_state_indicator.c
  group nRF_BLE
    ./nRF5_SDK10/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ./nRF5_SDK10/components/ble/ble_services/ble_bas/: ble_bas.c
    ./nRF5_SDK10/components/ble/ble_services/ble_dis/: ble_dis.c
    ./nRF5_SDK10/components/ble/ble_services/ble_hrs/: ble_hrs.c
    ./nRF5_SDK10/components/ble/device_manager/: device_manager_peripheral.c
    ./nRF5_SDK10/components/ble/ble_services/ble_gls/: ble_gls.c ble_gls_db.c
    ./nRF5_SDK10/components/ble/ble_racp/: ble_racp.c
  group nRF_Drivers
    ./nRF5_SDK10/components/libraries/uart/: app_uart.c
    ./nRF5_SDK10/components/drivers_nrf/delay/: nrf_delay.c
    ./nRF5_SDK10/components/drivers_nrf/common/: nrf_drv_common.c
    ./nRF5_SDK10/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ./nRF5_SDK10/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ./nRF5_SDK10/components/drivers_nrf/uart/: nrf_drv_uart.c
    ./nRF5_SDK10/components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ./nRF5_SDK10/components/libraries/button/: app_button.c
    ./nRF5_SDK10/components/libraries/util/: app_error.c nrf_assert.c nrf_log.c
    ./nRF5_SDK10/components/libraries/timer/: app_timer.c
    ./nRF5_SDK10/components/libraries/trace/: app_trace.c
    ./nRF5_SDK10/components/libraries/uart/: retarget.c
    ./nRF5_SDK10/components/libraries/sensorsim/: sensorsim.c
  group nRF_SoftDevice
    ./nRF5_SDK10/components/softdevice/s310/doc/: s310_nrf51822_3.0.0_licence_agreement.txt
    ./nRF5_SDK10/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Segger_RTT
    ./segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
target flash_s310_nrf51422_3.0.0_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.6.1
  cpu: as above
  output: s310_nrf51422_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  c include: .\config;.\nRF5_SDK10\components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD ANT_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
